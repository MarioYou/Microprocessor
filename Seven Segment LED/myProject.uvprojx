# Keil uVision project myProject.uvprojx, settings and files
target MyProgramSource (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mbed_blinky
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DMBED_BUILD_TIMESTAMP=1475787345.93 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DDEVICE_SLEEP=1 -Otime -DDEVICE_PORTINOUT=1 -DDEVICE_DEBUG_AWARENESS=1 -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 -DARM_MATH_CM4 -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 -DTARGET_LPC408X -DDEVICE_PORTIN=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -D__MBED_CMSIS_RTOS_CM -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_LPC4088
  c include: .; mbed/.; mbed/TARGET_LPC4088; mbed/TARGET_LPC4088/TARGET_NXP; mbed/TARGET_LPC4088/TARGET_NXP/TARGET_LPC408X; mbed/TARGET_LPC4088/TARGET_NXP/TARGET_LPC408X/TARGET_LPC4088; mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-DARM_MATH_CM4,-D__CORTEX_M4,-D__MBED_CMSIS_RTOS_CM,-D__FPU_PRESENT=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/LPC407X_8X.sct
  group TARGET_LPC4088
    mbed/TARGET_LPC4088/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h LPC407x_8x_177x_8x.h sys_helper.h system_LPC407x_8x_177x_8x.h
    mbed/TARGET_LPC4088/TARGET_NXP/TARGET_LPC408X/TARGET_LPC4088/: PeripheralNames.h PinNames.h
  group TARGET_LPC408X
    mbed/TARGET_LPC4088/TARGET_NXP/TARGET_LPC408X/: device.h gpio_object.h objects.h PortNames.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_LPC4088/TOOLCHAIN_ARM_STD/: cmsis_nvic.o mbed.ar mbed_board.o retarget.o startup_LPC407x_8x_177x_8x.o sys.o sys_helper.o system_LPC407x_8x_177x_8x.o
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Driver_Common.h Driver_Storage.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h pinmap.h platform.h PlatformMutex.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h SingletonPtr.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
  group MyProgram
    ./: main.cpp mbed_config.h
